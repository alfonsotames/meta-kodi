require kodi.inc
SRCREV="ca55c2cee796ad8f0e199c1945af7c3d82eec4ca"


PR = "${INC_PR}.1"

