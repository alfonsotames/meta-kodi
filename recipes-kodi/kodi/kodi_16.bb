require kodi.inc
SRCREV="4982009b56d184f8ce7890e947d0bd986e49828a"


PR = "${INC_PR}"

