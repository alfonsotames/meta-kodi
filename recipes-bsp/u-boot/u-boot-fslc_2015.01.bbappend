FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://Bump_HDMI_to_1080_32bpp.patch"


